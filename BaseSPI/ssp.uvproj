# Keil uVision project ssp.uvproj, settings and files
target SSP_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ssptest
  c flags: Optim=1
  c define: __DEBUG_RAM
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./: ssp.c ssptest.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11xx.c startup_LPC11xx.s
  group Common
    ../Common/src/: gpio.c uart.c
  group Read-me
    ./: readme.txt
target SSP_Release (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: ssptest
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
